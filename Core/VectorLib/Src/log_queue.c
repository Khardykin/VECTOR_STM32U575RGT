/**
  ******************************************************************************
  * @file    log_queue.c
  * @brief   Журнал v2: геометрия кольца и RAM-очередь записей (определения)
  *
  *          Замечание автора: «не надо держать функции в .h, это не красиво» -
  *          десять static inline из Config_save_read.h переехали сюда, в
  *          заголовке остались прототипы.
  *
  *          Файл ОТДЕЛЬНЫЙ от Config_save_read.c НАМЕРЕННО: тот включает
  *          main_vector.h (HAL, ThreadX, extstore-драйвер), поэтому хост-тест
  *          tools/test_logq не смог бы его скомпилировать, а смысл инлайнов
  *          был именно в общем коде («прошивочный писатель и хост-тест
  *          исполняют ОДИН И ТОТ ЖЕ код», шапка Config_save_read.h). Здесь -
  *          только чистая арифметика и structures из Config_save_read.h, без
  *          единого HAL-вызова: тест собирает этот .c как есть (Makefile
  *          tools/test_logq), прошивка - как обычный файл папки Core.
  *
  *          Содержимое (LOG_FORMAT.md):
  *            §2 геометрия кольца v2 - log_slot_addr_v2, log_erase_decision,
  *               log_archive_period_s, log_rec_valid;
  *            §6 RAM-очередь 16 × 40 Б - logq_init/count/full/push/peek/pop.
  *          Критическая секция (TX_DISABLE) и обращение к flash - на стороне
  *          Config_save_read.c (log_post/log_flush), здесь их нет.
  ******************************************************************************
  */
#include "Config_save_read.h"   /* типы EVENT_LOG/logq_ctx_t, LOG_* (и <string.h> transitively) */

//===========================================================================================================================
// ГЕОМЕТРИЯ КОЛЬЦА v2 (LOG_FORMAT.md §2)
//===========================================================================================================================
// Физический адрес слота по номеру указателя (§2). КОНТЕКСТ: любой, чистая
// арифметика (хост-тестируемо).
uint32_t log_slot_addr_v2(uint32_t log_base, uint32_t ptr)
{
	uint32_t phys = ptr % LOG_RING_SLOTS;
	return log_base
	     + (phys / LOG_SLOTS_PER_SECTOR) * LOG_SECTOR_SIZE
	     + (phys % LOG_SLOTS_PER_SECTOR) * LOG_SLOT_SIZE;
}

//===========================================================================================================================
// Решение о стирании перед записью на границу сектора (§2 «Переполнение»):
// 0 = писать без стирания, 1 = стереть сектор (слот не пуст), 2 = стереть и
// сдвинуть BegginAddrFile на LOG_SLOTS_PER_SECTOR (кольцо полное).
// blank - результат blank-пробы первого слота сектора (1 = все 0xFF);
// при full не используется. КОНТЕКСТ: любой, чистая арифметика.
//===========================================================================================================================
int log_erase_decision(uint32_t cur, uint32_t beg, int blank)
{
	uint32_t phys = cur % LOG_RING_SLOTS;
	if ((phys % LOG_SLOTS_PER_SECTOR) != 0u)
	{
		return 0;						// не на границе сектора
	}
	if ((uint32_t)(cur - beg) >= LOG_USABLE_SLOTS)
	{
		return 2;						// кольцо полное: стирание + сдвиг начала
	}
	return (blank != 0) ? 0 : 1;		// мусор старого формата/прошлых кругов
}

//===========================================================================================================================
// Archiveinterval ((мин<<8)|сек, §5) -> период архивного тика в секундах
// (uint16: максимум ~18 ч; countdown_time_rtc хранит uint16).
//===========================================================================================================================
uint16_t log_archive_period_s(uint16_t archive_interval)
{
	return (uint16_t)(((uint32_t)(archive_interval >> 8) * 60u)
	                + ((uint32_t)archive_interval & 0xFFu));
}

//===========================================================================================================================
// Валидность записи v2 (§7.1): Fmt_ver, известный Type_log, Payload_len <= 28.
//===========================================================================================================================
int log_rec_valid(const EVENT_LOG *r)
{
	switch (r->H.Type_log)
	{
	case TYPE_TURN_ON:  case TYPE_TURN_OFF: case TYPE_FW_UPDATE:
	case TYPE_READINGS: case TYPE_PARAM:    case TYPE_GAS:
	case TYPE_BEACONS:  case TYPE_PPE:      case TYPE_SNAPSHOT:
		break;
	default:
		return 0;
	}
	return ((r->H.Fmt_ver == LOG_FMT_VER) && (r->H.Payload_len <= LOG_PAYLOAD_MAX)) ? 1 : 0;
}

//===========================================================================================================================
// RAM-ОЧЕРЕДЬ ЗАПИСЕЙ (LOG_FORMAT.md §6): кольцо 16 × 40 Б = 640 Б.
// Снимок (время/состояние/данные) делается В МОМЕНТ СОБЫТИЯ (log_post) -
// задержка записи во flash время записи НЕ искажает; всплески не теряются
// (FIFO сохраняет хронологию - бинарный поиск по времени остаётся корректным).
//===========================================================================================================================
void logq_init(logq_ctx_t *q)
{
	q->head  = 0u;
	q->count = 0u;
}

//===========================================================================================================================
uint32_t logq_count(const logq_ctx_t *q)
{
	return (uint32_t)q->count;
}

//===========================================================================================================================
int logq_full(const logq_ctx_t *q)
{
	return (q->count >= (uint8_t)LOGQ_SLOTS) ? 1 : 0;
}

//===========================================================================================================================
// Постановка в очередь. Возврат: 0 = поставлена, 1 = очередь была полна -
// СТАРЕЙШАЯ перезаписана (вызывающий считает потерю и печатает LOG_E, §6).
//===========================================================================================================================
int logq_push(logq_ctx_t *q, const EVENT_LOG *r)
{
	uint8_t tail = (uint8_t)((uint32_t)(q->head + q->count) % LOGQ_SLOTS);
	int over = 0;

	q->rec[tail] = *r;
	if (q->count >= (uint8_t)LOGQ_SLOTS)
	{
		// полная: tail == head (слот старейшей) - новая запись встаёт на её
		// место, head сдвигается: FIFO сохраняется, старейшая теряется.
		q->head = (uint8_t)((q->head + 1u) % LOGQ_SLOTS);
		over = 1;
	}
	else
	{
		q->count++;
	}
	return over;
}

//===========================================================================================================================
// Старейшая запись без извлечения (NULL = очередь пуста).
//===========================================================================================================================
const EVENT_LOG *logq_peek(const logq_ctx_t *q)
{
	return (q->count != 0u) ? &q->rec[q->head] : (const EVENT_LOG *)0;
}

//===========================================================================================================================
// Извлечь старейшую (после успешной записи во flash). Пустая - no-op.
//===========================================================================================================================
void logq_pop(logq_ctx_t *q)
{
	if (q->count != 0u)
	{
		q->head = (uint8_t)((q->head + 1u) % LOGQ_SLOTS);
		q->count--;
	}
}
